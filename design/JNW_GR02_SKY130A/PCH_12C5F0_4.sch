v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {JNW_ATR_SKY130A/JNWATR_PCH_12C5F0.sym} -110 -50 0 0 {name=xd1}
C {JNW_ATR_SKY130A/JNWATR_PCH_12C5F0.sym} -200 -50 0 0 {name=xd2}
C {JNW_ATR_SKY130A/JNWATR_PCH_12C5F0.sym} -30 -50 0 0 {name=xd3}
C {JNW_ATR_SKY130A/JNWATR_PCH_12C5F0.sym} 50 -50 0 0 {name=xd4}
C {devices/iopin.sym} -270 20 0 0 {name=p3 lab=S}
C {devices/iopin.sym} -270 -90 0 0 {name=p1 lab=D}
C {devices/iopin.sym} -270 -60 0 0 {name=p2 lab=G}
C {devices/iopin.sym} -270 -10 0 0 {name=p4 lab=B}
C {devices/lab_pin.sym} -160 -20 2 0 {name=l0 sig_type=std_logic lab=D }
C {devices/lab_pin.sym} -200 -50 0 0 {name=l1 sig_type=std_logic lab=G }
C {devices/lab_pin.sym} -160 -80 2 0 {name=l2 sig_type=std_logic lab=S }
C {devices/lab_pin.sym} -160 -50 2 0 {name=l3 sig_type=std_logic lab=B }
C {devices/lab_pin.sym} -70 -20 2 0 {name=l4 sig_type=std_logic lab=D }
C {devices/lab_pin.sym} -110 -50 0 0 {name=l5 sig_type=std_logic lab=G }
C {devices/lab_pin.sym} -70 -80 2 0 {name=l6 sig_type=std_logic lab=S }
C {devices/lab_pin.sym} -70 -50 2 0 {name=l7 sig_type=std_logic lab=B }
C {devices/lab_pin.sym} 10 -20 2 0 {name=l8 sig_type=std_logic lab=D }
C {devices/lab_pin.sym} -30 -50 0 0 {name=l9 sig_type=std_logic lab=G }
C {devices/lab_pin.sym} 10 -80 2 0 {name=l10 sig_type=std_logic lab=S }
C {devices/lab_pin.sym} 10 -50 2 0 {name=l11 sig_type=std_logic lab=B }
C {devices/lab_pin.sym} 90 -20 2 0 {name=l12 sig_type=std_logic lab=D }
C {devices/lab_pin.sym} 50 -50 0 0 {name=l13 sig_type=std_logic lab=G }
C {devices/lab_pin.sym} 90 -80 2 0 {name=l14 sig_type=std_logic lab=S }
C {devices/lab_pin.sym} 90 -50 2 0 {name=l15 sig_type=std_logic lab=B }
