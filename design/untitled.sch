v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Visnar Temperature to Current} -920 -600 0 0 1 1 {}
